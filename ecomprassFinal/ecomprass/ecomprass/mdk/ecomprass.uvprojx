# Keil uVision project ecomprass.uvprojx, settings and files
target ecomprass (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: CPUTYPE("Cortex-M0+")
  output: ecomprass.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../..;..
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  group source
    ../: ecomprass.c
    ./: slcd.h slcd.c
target ecomprass release (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: CPUTYPE("Cortex-M0+")
  output: i2c_read_accel_value_transfer.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM, PRINTF_ADVANCED_ENABLE=1
  c misc: as above
  c include: ../../../..;..
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
software components: CMSIS:CORE 5.0.1, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:gpio 2.2.1, Device:SDK Drivers:i2c 2.0.5, Device:SDK Drivers:lpsci 2.0.4, Device:SDK Drivers:port 2.0.2, Device:SDK Drivers:smc 2.0.3, Device:SDK Drivers:uart 2.1.5, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:Startup 1.0.0
